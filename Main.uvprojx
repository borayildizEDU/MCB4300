# Keil uVision project Main.uvprojx, settings and files
target LPC4357 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.7.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x12000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(204000000) ELITTLE
  output: Main
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 v6LangP=3
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: LED.cpp LED.h Main.cpp LCD.cpp LCD.h
  group Documentation
    ./: Abstract.txt
target LPC4357 RAM (5060020::V5.06 (build 20)::ARMCC)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.7.0
  cpu: as above
  output: Main
  c flags: Optim=1
  memory RVCT4: ROM 0x10000000 size 0x12000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Graphic LCD 1.0.0, Board Support:LED 1.0.0, CMSIS Driver:SPI 2.6, CMSIS Driver:SPI:SSP 2.10, Device:GPDMA 1.5, Device:GPIO 1.0, Device:SCU 1.1, Device:Startup 1.0.0
